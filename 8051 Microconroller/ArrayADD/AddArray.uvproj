# Keil uVision project AddArray.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LP51RD2 Atmel
  cpu: IRAM(0x00-0xFF) XRAM(0x000-0x7FF) IROM(0x0000-0xFFFF) CLOCK(20000000)
  output: AddArray +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Add.asm AvgArray.asm Mul32.asm
